# IAR project TEST.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: C:\Texas Instruments\Z-Stack 3.0.1\Components\hal\include; C:\Texas Instruments\Z-Stack 3.0.1\Components\hal\common; C:\Texas Instruments\Z-Stack 3.0.1\Components\hal\target\CC2530EB; C:\Texas Instruments\Z-Stack 3.0.1\Components\osal\common; C:\Texas Instruments\Z-Stack 3.0.1\Components\osal\include; C:\Texas Instruments\Z-Stack 3.0.1\Components\osal\mcu\cc2530
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
configuration Release (8051)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  group (top)
    ./: main.cpp
