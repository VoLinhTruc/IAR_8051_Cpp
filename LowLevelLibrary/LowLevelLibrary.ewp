# IAR project LowLevelLibrary.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\LowLevelLibrary\inc; ..\ArduinoJson; ..\ArduinoJson\ArduinoJson; ..\ArduinoJson\ArduinoJson\Data; ..\ArduinoJson\ArduinoJson\Deserialization; ..\ArduinoJson\ArduinoJson\Polyfills; ..\ArduinoJson\ArduinoJson\Serialization; ..\ArduinoJson\ArduinoJson\StringTraits; ..\ArduinoJson\ArduinoJson\TypeTraits
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCIncludePath2: C:\Users\Bico\Desktop\IAR 8051 C++\LowLevelLibrary\inc
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  group (top)
    ./: main.cpp
  group inc
    inc/: ADC.h ExINT.h Generic.h GlobalINT.h GPIO.h UART.h
  group src
    src/: ADC.c ExINT.c Generic.c GlobalINT.c GPIO.c UART.c
