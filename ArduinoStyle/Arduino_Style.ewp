# IAR project Arduino_Style.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: C:\Users\Bico\Desktop\IAR 8051 C++\ArduinoStyle\inc; C:\Users\Bico\Desktop\IAR 8051 C++\LowLevelLibrary\inc
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
  group (top)
    ./: main.cpp
  group inc
    inc/: Algebra_Math.h Bico_Port.h Bico_Seg7.h CCINO_GPIO.h Logic_Math.h
  group scr
    ../LowLevelLibrary/src/: ADC.c ExINT.c Generic.c GlobalINT.c GPIO.c UART.c
    scr/: CCINO_GPIO.c
